IMAGE_INSTALL += " \
	packagegroup-target-workshop \
	packagegroup-target-workshop-qt \
	"

