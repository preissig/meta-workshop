TOOLCHAIN_HOST_TASK += " \
	nativesdk-packagegroup-host-workshop \
	nativesdk-packagegroup-host-workshop-qt \
	"

