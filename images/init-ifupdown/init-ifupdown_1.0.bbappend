# replace the interface file with our own
# requires the BBFILE_PRIORITY in layer.conf be set to a higher value
#	than that of the arago distro overlay 
FILESEXTRAPATHS_prepend_am335x-evm := "${THISDIR}/am335x-evm:"



