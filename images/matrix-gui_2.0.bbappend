# Remove the rcX.d init script link for matrix gui
# INITSCRIPT_PACKAGES defaults to ${PN} to add an init script for this package
INITSCRIPT_PACKAGES = ""

