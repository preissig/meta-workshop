# extend the basic lab recipe to include pthread library
LDFLAGS += "-lpthread"
