SRC_URI = "http://dev.gateworks.com/sources/evtest-${PV}.tar.bz2;name=archive"
