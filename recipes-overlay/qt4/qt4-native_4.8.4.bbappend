EXTRA_OECONF += " \
	-qt-gfx-qvfb \
	-qt-gfx-linuxfb \
	"

